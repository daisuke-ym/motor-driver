# Repository daisuke-ym/motor-driver

## KiCad design pcb/motor-driver2026a/motor-driver2026a.kicad_pcb

Parts:
C1, C2: 2.2u; C_0603_1608Metric; LCSC C23630
C3, C5: 0.1u; C_0402_1005Metric; LCSC C1525
C4: 0.22u; C_0805_2012Metric; LCSC C5378
D1, D2: 1N5819WS; D_SOD-323; LCSC C191023
J1: INPUT; TB111-2-2
J2: POWER; TB111-2-2
J3: POWER; BarrelJack_Horizontal
J4: UPDI; PinSocket_1x03_P2.54mm_Vertical
J5: MOTOR; TB111-2-2
Q1, Q3: AO3401A; SOT-23; LCSC C15127
Q2, Q4: AO3400A; SOT-23; LCSC C20917
R1, R2, R5, R6, R7, R8: 10k; R_0402_1005Metric; LCSC C25744
R3, R4, R9, R10: 10; R_0402_1005Metric; LCSC C25077
RV1: CW/CCW; RV100F-30-6K3B-B10K-B301
SW1: TEST1; TS-1088-AR02016; LCSC C720477
SW2: TEST2; TS-1088-AR02016; LCSC C720477
SW3: MODE; SS12D01G4
U1: ATtiny1604-SS; SOIC-14_3.9x8.7mm_P1.27mm
U2: L78L05_SOT89; SOT-89-3; LCSC C71136

Connections:
+5V: C3.2, C5.1, J4.1, RV1.1, SW1.2 (B), SW2.2 (B), U1.1 (VCC), U2.1 (OUT)
+BATT: C4.1, J2.1, J3.1, Q1.2 (S), Q3.2 (S), R5.1, R7.1, U2.3 (IN)
/IN1: C1.1, R1.2, U1.4 (PA6)
/IN2: C2.1, R2.2, U1.3 (PA5)
/M1A: R3.1, U1.12 (PA2)
/M1B: R9.2, U1.2 (PA4)
/M1C: R4.1, U1.11 (PA1)
/M1D: R10.2, U1.13 (PA3)
/UPDI: J4.3, U1.10 (~RESET/PA0)
/VR: RV1.2, U1.9 (PB0)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, J2.2, J3.2, J4.2, Q2.2 (S), Q4.2 (S), R6.2, R8.2, RV1.3, SW3.2 (B), U1.14 (GND), U2.2 (GND)
unnamed: D1.2 (A), J1.1
unnamed: D1.1 (K), R1.1, SW1.1 (A)
unnamed: D2.2 (A), J1.2
unnamed: D2.1 (K), R2.1, SW2.1 (A)
unnamed: J5.1, Q3.3 (D), Q4.3 (D)
unnamed: J5.2, Q1.3 (D), Q2.3 (D)
unnamed: Q1.1 (G), R3.2, R5.2
unnamed: Q2.1 (G), R4.2, R6.1
unnamed: Q3.1 (G), R7.2, R9.1
unnamed: Q4.1 (G), R8.1, R10.1
unnamed: SW3.1 (A), U1.5 (PA7)

Notes on the sheet:
MODEスイッチで動作モードを選択する MODE1: 外部入力による動作 MODE2: 基板実装VRによる動作
電源選択回路 POWER SELECTスイッチでマイコンの電源を BATT端子と+5V端子のどちらかを使うか選択する
外部入力（PWM信号）はRC積分回路を経由して平滑する マイコンはA/D変換して処理する テストスイッチからの電流がコントローラー側に逆流しないように ショットキーダイオードを入れている分、入力電圧が約0.6V下がる
Hブリッジ回路 +側にP-MOSFET、-側にN-MOSFETを使用している P-MOSはプルアップしてLOWアクティブ N-MOSはプルダウンしてHIGHアクティブ デッドタイムはマイコンで生成する PWM動作はN-MOS側のみ （P-MOSよりN-MOSの方がスイッチング性能が高いため）

Board: 2 copper layers, 50.0 x 50.0 mm, 32 parts (0 on the bottom side), 22 nets.

File pcb/motor-driver2026a/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2",0603,2,2.2u,C23630
"C3, C5",0402,2,0.1u,C1525
C4,0805,1,0.22u,C5378
"D1, D2",D_SOD-323,2,1N5819WS,C191023
J1,TB111-2-2,1,INPUT,
J2,TB111-2-2,1,POWER,
J3,BarrelJack_Horizontal,1,POWER,
J4,PinSocket_1x03_P2.54mm_Vertical,1,UPDI,
J5,TB111-2-2,1,MOTOR,
"Q1, Q3",SOT-23,2,AO3401A,C15127
"Q2, Q4",SOT-23,2,AO3400A,C20917
"R1, R2, R5, R6, R7, R8",0402,6,10k,C25744
"R10, R3, R4, R9",0402,4,10,C25077
RV1,RV100F-30-6K3B-B10K-B301,1,CW/CCW,
SW1,TS-1088-AR02016,1,TEST1,C720477
SW2,TS-1088-AR02016,1,TEST2,C720477
SW3,SS12D01G4,1,MODE,
U1,SOIC-14_3.9x8.7mm_P1.27mm,1,ATtiny1604-SS,
U2,SOT-89-3,1,L78L05_SOT89,C71136

## KiCad design pcb/motor-driver-tpc8408/motor-driver-tpc8408.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric
J1: Conn_01x12; PinHeader_1x12_P2.54mm_Horizontal
R1, R2, R7, R8: 20; R_0603_1608Metric
R3, R4, R5, R6: 2k2; R_0603_1608Metric
U1, U2: FDS4559; SOIC-8_3.9x4.9mm_P1.27mm
U3: 74HC00; TSSOP-14_4.4x5mm_P0.65mm

Connections:
/IN_A: J1.7, R8.1, U3.5, U3.12, U3.13
/IN_B: J1.8, R2.2, U3.1, U3.2, U3.9
/M1: J1.1, J1.2, U1.5 (D), U1.6 (D), U1.7 (D), U1.8 (D)
/M2: J1.11, J1.12, U2.5 (D), U2.6 (D), U2.7 (D), U2.8 (D)
/P1: R1.2, U3.6
/P2: R7.1, U3.8
/VM1: J1.3, J1.4, R3.1, R5.2, U1.3 (1), U2.3 (1)
/VM2: J1.9, J1.10, R4.2, R6.2, U1.1 (S), U2.1 (S)
GND: C1.2, J1.6, U3.7 (GND)
unnamed: R2.1, R4.1, U1.2 (G)
unnamed: R1.1, R3.2, U1.4 (G)
unnamed: R6.1, R8.2, U2.2 (G)
unnamed: R5.1, R7.2, U2.4 (G)
unnamed: U3.3, U3.4
unnamed: U3.10, U3.11
VCC: C1.1, J1.5, U3.14 (VCC)

Notes on the sheet:
こちらがマイナス側
STOP
こちらがプラス側
貫通電流防止ロジック
IN_A
IN_B
BRAKE
CCW

Board: 2 copper layers, 33.0 x 21.0 mm, 13 parts (1 on the bottom side), 16 nets.

File pcb/motor-driver-tpc8408/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1_8, C1_7, C1_6, C1_5, C1_4, C1_3, C1_2, C1",0603,8,0.1u,
"J1_8, J1_7, J1_6, J1_5, J1_4, J1_3, J1_2, J1",PinHeader_1x12_P2.54mm_Horizontal,8,Conn_01x12,
"R1_8, R1_7, R1_6, R1_5, R1_4, R1_3, R1_2, R1, R2_8, R2_7, R2_6, R2_5, R2_4, R2_3, R2_2, R2, R7_8, R7_7, R7_6, R7_5, R7_4, R7_3, R7_2, R7, R8_8, R8_7, R8_6, R8_5, R8_4, R8_3, R8_2, R8",0603,32,20,
"R3_8, R3_7, R3_6, R3_5, R3_4, R3_3, R3_2, R3, R4_8, R4_7, R4_6, R4_5, R4_4, R4_3, R4_2, R4, R5_8, R5_7, R5_6, R5_5, R5_4, R5_3, R5_2, R5, R6_8, R6_7, R6_6, R6_5, R6_4, R6_3, R6_2, R6",0603,32,2k2,
"U1_8, U1_7, U1_6, U1_5, U1_4, U1_3, U1_2, U1, U2_8, U2_7, U2_6, U2_5, U2_4, U2_3, U2_2, U2",SOIC-8_3.9x4.9mm_P1.27mm,16,FDS4559,
"U3_8, U3_7, U3_6, U3_5, U3_4, U3_3, U3_2, U3",TSSOP-14_4.4x5mm_P0.65mm,8,74HC00,

## KiCad design pcb/object-sensor2022a/object-sensor2022a.kicad_pcb

Parts:
C1: 0.1u; C_Disc_D3.4mm_W2.1mm_P2.50mm
D1: IR LED; LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm
D2: YELLOW; LED_D3.0mm_Clear
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Horizontal
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 4K7; GF063P1
U1: S6809; S6809_Horizontal_Facedown

Connections:
+5V: C1.1, J1.1, R1.2, R2.1, RV1.1, RV1.2, U1.4 (Vcc)
/WS1: D2.1 (K), J1.2, R1.1, U1.1 (Vout)
GND: C1.2, J1.3, U1.2 (GND)
unnamed: D1.1 (K), U1.3 (Cathod)
unnamed: D1.2 (A), RV1.3
unnamed: D2.2 (A), R2.2

Notes on the sheet:
Wall Sensor

Board: 2 copper layers, 50.0 x 18.0 mm, 10 parts (0 on the bottom side), 6 nets.

Other parts of the board:
MH1, MH2: MountingHole_3.2mm_M3

## KiCad design pcb/line-sensor/line-sensor.kicad_pcb

Parts:
C1: 0.1u; C_Disc_D5.0mm_W2.5mm_P2.50mm
D1, D3, D9, D11: RED; LED_D3.0mm_Clear
D2, D10: BLUE; LED_D3.0mm_Clear
D4, D5, D6, D12, D13, D14: IR LED; LED_D3.0mm_Clear
D7: YELLOW; LED_D3.0mm_Clear
D8: IR LED; LED_D3.0mm_Horizontal_O3.81mm_Z6.0mm
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J2: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1: 10k; R_Array_SIP9
RV1, RV2, RV3, RV4, RV5, RV6, RV7: 4K7; TSR-065
U1, U2, U3, U5, U6, U7: S7136
U4: S6809; S6809_Horizontal_Facedown

Connections:
+5V: C1.1, J1.1, J2.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, RN1.1 (common), RV1.1, RV1.2, RV2.1, RV2.2, RV3.1, RV3.2, RV4.1, RV4.2, RV5.1, RV5.2, RV6.1, RV6.2, RV7.1, RV7.2, U1.2 (Vcc), U2.2 (Vcc), U3.2 (Vcc), U4.4 (Vcc), U5.2 (Vcc), U6.2 (Vcc), U7.2 (Vcc)
/LS1: D3.1 (K), J1.6, J2.6, RN1.6 (R5), U3.3 (Vout)
/LS2: D2.1 (K), J1.7, J2.7, RN1.7 (R6), U2.3 (Vout)
/LS3: D1.1 (K), J1.8, J2.8, RN1.8 (R7), U1.3 (Vout)
/RS1: D9.1 (K), J1.4, J2.4, RN1.4 (R3), U5.3 (Vout)
/RS2: D10.1 (K), J1.3, J2.3, RN1.3 (R2), U6.3 (Vout)
/RS3: D11.1 (K), J1.2, J2.2, RN1.2 (R1), U7.3 (Vout)
/WS1: D7.1 (K), J1.5, J2.5, RN1.5 (R4), U4.1 (Vout)
GND: C1.2, J1.10, J2.10, U1.4 (GND), U2.4 (GND), U3.4 (GND), U4.2 (GND), U5.4 (GND), U6.4 (GND), U7.4 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.1 (K), U1.1 (Cathod)
unnamed: D4.2 (A), RV1.3
unnamed: D5.1 (K), U2.1 (Cathod)
unnamed: D5.2 (A), RV2.3
unnamed: D6.1 (K), U3.1 (Cathod)
unnamed: D6.2 (A), RV3.3
unnamed: D7.2 (A), R4.2
unnamed: D8.1 (K), U4.3 (Cathod)
unnamed: D8.2 (A), RV4.3
unnamed: D9.2 (A), R5.2
unnamed: D10.2 (A), R6.2
unnamed: D11.2 (A), R7.2
unnamed: D12.1 (K), U5.1 (Cathod)
unnamed: D12.2 (A), RV5.3
unnamed: D13.1 (K), U6.1 (Cathod)
unnamed: D13.2 (A), RV6.3
unnamed: D14.1 (K), U7.1 (Cathod)
unnamed: D14.2 (A), RV7.3

Notes on the sheet:
Right Sensor 3 (outer side)
Right Sensor 2
Right Sensor 1 (inner side)
Wall Sensor
Left Sensor 3 (outer side)
Left Sensor 2
Left Sensor 1 (inner side)

Board: 2 copper layers, 140.0 x 40.0 mm, 55 parts (6 on the bottom side), 30 nets.

Other parts of the board:
LH1, LH2, LH3, LH4, LH5, LH6: MountingHole_3.2mm_M3
MH1, MH2, MH3, MH4, MH5, MH6, MH7, MH8, MH9, MH10: MountingHole_3.2mm_M3

## KiCad design pcb/motor-driver5/motor-driver5.kicad_pcb

Parts:
C1, C2, C3, C4: 10u; CP_Radial_D4.0mm_P1.50mm
C5, C6: 0.1u; C_Disc_D3.0mm_W2.0mm_P2.50mm
J1: Motor Power; JST_VH_B2PS-VH_1x02_P3.96mm_Horizontal
J2: Logic Power; PinHeader_1x02_P2.54mm_Horizontal
J3: Input Ch1; PinHeader_1x02_P2.54mm_Horizontal
J4: Input Ch2; PinHeader_1x02_P2.54mm_Horizontal
M1, M2: Motor_DC; JST_VH_B2PS-VH_1x02_P3.96mm_Horizontal
Q1, Q3, Q5, Q7: Q_PMOS_GDS; TO-220F-3_Vertical
Q2, Q4, Q6, Q8: Q_NMOS_GDS; TO-220F-3_Vertical
R1, R2, R3, R4: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R5, R6, R9, R10, R13, R14, R17, R18: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R7, R8, R11, R12, R15, R16, R19, R20: 2k2; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
U1, U2: ATtiny85-20PU; DIP-8_W7.62mm
U3, U4, U5, U6, U7, U8, U9, U10: TLP785; DIP-4_W7.62mm

Connections:
+5V: C5.1, C6.1, J2.1, U1.8 (VCC), U2.8 (VCC)
+BATT: J1.1, Q1.3 (S), Q3.3 (S), Q5.3 (S), Q7.3 (S), R7.2, R11.2, R15.2, R19.2, U4.4, U6.4, U8.4, U10.4
/IN1A: J3.1, R1.1
/IN1AA: C1.1, R1.2, U1.2 (XTAL1/PB3)
/IN1B: J3.2, R2.1
/IN1BA: C2.1, R2.2, U1.3 (XTAL2/PB4)
/IN2A: J4.1, R3.1
/IN2AA: C3.1, R3.2, U2.2 (XTAL1/PB3)
/IN2B: J4.2, R4.1
/IN2BA: C4.1, R4.2, U2.3 (XTAL2/PB4)
/PC1A: R5.1, R10.1, U1.5 (AREF/PB0)
/PC1B: R6.1, R9.1, U1.6 (PB1)
/PC2A: R13.1, R18.1, U2.5 (AREF/PB0)
/PC2B: R14.1, R17.1, U2.6 (PB1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J2.2, U1.4 (GND), U2.4 (GND), U3.2, U4.2, U5.2, U6.2, U7.2, U8.2, U9.2, U10.2
GNDPWR: J1.2, Q2.3 (S), Q4.3 (S), Q6.3 (S), Q8.3 (S), R8.1, R12.1, R16.1, R20.1, U3.3, U5.3, U7.3, U9.3
unnamed: M1.1 (+), Q3.2 (D), Q4.2 (D)
unnamed: M1.2 (-), Q1.2 (D), Q2.2 (D)
unnamed: M2.1 (+), Q7.2 (D), Q8.2 (D)
unnamed: M2.2 (-), Q5.2 (D), Q6.2 (D)
unnamed: Q1.1 (G), R7.1, U3.4
unnamed: Q2.1 (G), R8.2, U4.3
unnamed: Q3.1 (G), R11.1, U5.4
unnamed: Q4.1 (G), R12.2, U6.3
unnamed: Q5.1 (G), R15.1, U7.4
unnamed: Q6.1 (G), R16.2, U8.3
unnamed: Q7.1 (G), R19.1, U9.4
unnamed: Q8.1 (G), R20.2, U10.3
unnamed: R5.2, U3.1
unnamed: R6.2, U4.1
unnamed: R9.2, U5.1
unnamed: R10.2, U6.1
unnamed: R13.2, U7.1
unnamed: R14.2, U8.1
unnamed: R17.2, U9.1
unnamed: R18.2, U10.1

Board: 2 copper layers, 72.0 x 54.0 mm, 50 parts (0 on the bottom side), 36 nets.
